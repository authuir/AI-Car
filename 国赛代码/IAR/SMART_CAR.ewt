<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>project</name>
    <file>
      <name>$PROJ_DIR$\my ku\project\Catch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\Catch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\keyboard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\keyboard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\line_math.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\line_math.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\PID.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\PID.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\project.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\project.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\rollway.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\rollway.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\SCCB.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\TFT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\project\TFT.h</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <file>
      <name>$PROJ_DIR$\my ku\src\ADC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\ADC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\all.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\DAC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\DAC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\DMA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\DMA.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\FTM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\FTM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\FTM2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\FTM2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\GPIO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\GPIO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\I2C.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\I2C.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\INT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\INT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\LCD.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\lptmr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\PIT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\SD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\SD.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\SPI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\SPI.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\systick.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\UART.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\UART.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\WDOG.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\my ku\src\WDOG.h</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\startup_MK60F15.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\system_MK60F15.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
  </group>
</project>


