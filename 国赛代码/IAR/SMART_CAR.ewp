# IAR project SMART_CAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; my ku; my ku\src; my ku\project
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: SMART_CAR.srec
  ILINK.IlinkOutputFile: SMART_CAR.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Freescale\MK60xN1M_15.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group project
    my ku/project/: Catch.c Catch.h keyboard.c keyboard.h line_math.c line_math.h PID.c PID.h project.c project.h rollway.c rollway.h SCCB.c SCCB.h TFT.c TFT.h
  group src
    my ku/src/: ADC.c ADC.h all.h common.c common.h DAC.c DAC.h DMA.c DMA.h FTM.c FTM.h FTM2.c FTM2.h GPIO.c GPIO.h I2C.c I2C.h INT.c INT.h LCD.c LCD.h lptmr.c lptmr.h PIT.c PIT.h SD.c SD.h SPI.c SPI.h systick.c systick.h UART.c UART.h WDOG.c WDOG.h
  group startup
    ./: startup_MK60F15.s system_MK60F15.c
  group user
    ./: main.c
