<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\..\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MKL_it.c</name>
    </file>
  </group>
  <group>
    <name>Chip</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_TPM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MKL_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\startup_MKL.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\system_MKL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\vectors.c</name>
    </file>
  </group>
  <group>
    <name>INC</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\all.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\misc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_BME.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_dac.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_gpio_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_lptmr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_mcg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_PIT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_SysTick.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_TPM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MKL_wdog.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\PORT_cfg.h</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\iar_cortexM0plusl_math.a</name>
      </file>
    </group>
  </group>
  <group>
    <name>project</name>
    <file>
      <name>$PROJ_DIR$\..\..\project\Catch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\Catch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\IR.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\IR.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\keyboard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\keyboard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\LCD.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\line_math.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\line_math.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\PID.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\PID.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\project.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\project.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\rollway.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\rollway.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\SCCB.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\TFT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\project\TFT.H</name>
    </file>
  </group>
</project>


