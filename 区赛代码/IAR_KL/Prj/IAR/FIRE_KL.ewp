# IAR project FIRE_KL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\project; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\SD_CARD
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FIRE_KL.hex
  ILINK.IlinkOutputFile: FIRE_KL.out
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: main.c MKL_it.c
  group Chip
    ../../Chip/Src/: conf.c misc.c MKL_adc.c MKL_dac.c MKL_dma.c MKL_flash.c MKL_gpio.c MKL_i2c.c MKL_lptmr.c MKL_mcg.c MKL_PIT.c MKL_port.c MKL_spi.c MKL_SysTick.c MKL_TPM.c MKL_uart.c MKL_wdog.c
    ../../Chip/Src/IAR/: startup_MKL.s system_MKL.c vectors.c
  group INC
    ../../Chip/Inc/: all.h common.h conf.h misc.h MKL_adc.h MKL_BME.h MKL_dac.h MKL_dma.h MKL_flash.h MKL_gpio.h MKL_gpio_cfg.h MKL_i2c.h MKL_lptmr.h MKL_mcg.h MKL_PIT.h MKL_port.h MKL_spi.h MKL_SysTick.h MKL_TPM.h MKL_uart.h MKL_wdog.h PORT_cfg.h
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM0plusl_math.a
  group project
    ../../project/: Catch.c Catch.h IR.c IR.h keyboard.c keyboard.h LCD.c LCD.h line_math.c line_math.h PID.c PID.h project.c project.h rollway.c rollway.h SCCB.c SCCB.h TFT.c TFT.H
