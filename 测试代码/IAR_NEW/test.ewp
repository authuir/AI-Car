# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; my ku\src; my ku\lib; my ku\lib\dmp; my ku\project
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group my ku/src
    my ku/src/: ADC.c ADC.h all.h common.c common.h DAC.c DAC.h DMA.c DMA.h FTM.c FTM.h GPIO.c GPIO.h I2C.c I2C.h I2C_moni.c I2C_moni.h INT.c INT.h LCD.c LCD.h PIT.c PIT.h SD.c SD.h SPI.c SPI.h systick.c systick.h UART.c UART.h WDOG.c WDOG.h
  group projiect
    my ku/project/: project.c project.h SCCB.c SCCB.h TFT.c TFT.h
  group startup
    ./: startup_MK60F15.s system_MK60F15.c
  group user
    ./: main.c
